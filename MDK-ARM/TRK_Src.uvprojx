# Keil uVision project TRK_Src.uvprojx, settings and files
target TRK_Src (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L476JGYx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TRK_Src
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: TRK_Src\TRK_Src.sct
  link misc: --diag_suppress=L6329 --keep=*(.image_uuid) --keep=*(.image_crc) --keep=*(.image_len) --keep=*(.image_maj) --keep=*(.image_min)
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c tasks.c timers.c list.c queue.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Application/User
    ../Src/: user_diskio.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c stm32l4xx_it.c fatfs.c freertos.c main.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_lptim.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc.c stm32l4xx_hal_rtc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group ODM
    ../ODM/: bmApi.c bmSrv.c cmApi.c cmSrv.c fmApi.c genApi.c gmApi.c gmSrv.c mmApi.c mmSrv.c pmApi.c pmSrv.c smApi.c smSrv.c testApp.c wmApi.c wmSrv.c uart.c HTS221_Driver.c LIS2DH12_driver.c genSrv.c
software components: CMSIS:CORE 4.1.0
